Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: \\local.beekgroepnas.nl\Beek Deuren\9_Projecten\Beek Deuren\2025\22250540 Beek Deuren Deurentest freesproject\5) Tekeningen\Tekeningen definitief\Standaarddeur\LPDK std Rechtsdraaiend 008580 Deur 1 V1.IFC
Time: 2026-02-23T14:18:11+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
